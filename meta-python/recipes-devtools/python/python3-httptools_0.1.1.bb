SUMMARY = "A collection of framework independent HTTP protocol utils"
HOMEPAGE = "https://github.com/MagicStack/httptools"
LICENSE = "MIT"

inherit pypi setuptools3

SRC_URI[md5sum] = "063a9b6f8c79cf5f11592e7a49715275"
SRC_URI[sha256sum] = "41b573cf33f64a8f8f3400d0a7faf48e1888582b6f6e02b82b9bd4f0bf7497ce"
