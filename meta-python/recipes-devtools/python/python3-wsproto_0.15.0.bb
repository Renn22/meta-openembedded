SUMMARY = "WebSockets state-machine based protocol implementation"
HOMEPAGE = "https://github.com/python-hyper/wsproto/"
LICENSE = "MIT"

inherit pypi setuptools3

SRC_URI[md5sum] = "7d85f66da7ca9945b8bbfb8134900057"
SRC_URI[sha256sum] = "614798c30e5dc2b3f65acc03d2d50842b97621487350ce79a80a711229edfa9d"
