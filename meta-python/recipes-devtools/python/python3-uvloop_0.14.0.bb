SUMMARY = "Fast implementation of asyncio event loop on top of libuv"
HOMEPAGE = "http://github.com/MagicStack/uvloop"
LICENSE = "MIT"

inherit pypi setuptools3

SRC_URI[md5sum] = "a2f82abb676756f11f544c6b51caf171"
SRC_URI[sha256sum] = "123ac9c0c7dd71464f58f1b4ee0bbd81285d96cdda8bc3519281b8973e3a461e"
