SUMMARY = "A pure-Python, bring-your-own-I/O implementation of HTTP/1.1"
HOMEPAGE = "https://github.com/python-hyper/h11"
LICENSE = "MIT"

inherit pypi setuptools3

SRC_URI[md5sum] = "53affae306153388512040e038519fa3"
SRC_URI[sha256sum] = "33d4bca7be0fa039f4e84d50ab00531047e53d6ee8ffbc83501ea602c169cae1"
